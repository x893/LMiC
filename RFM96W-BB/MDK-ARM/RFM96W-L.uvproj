# Keil uVision project RFM96W-L.uvproj, settings and files
target RFM98W-L CLIENT (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RFM96W-L Configuration
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB IS_CLIENT
  c include: ..\Inc; ..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\RadioHead
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../RadioHead/: RFM98W.c
    ../Src/: stm32l1xx_it.c main.c usbd_conf.c usbd_desc.c stm32l1xx_hal_msp.c usb_device.c usbd_cdc_if.c md5.c
    ../Inc/: board.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_uart.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_cortex.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pcd.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_flash.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xb.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
target RFM98W-L SERVER (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: RFM96W-L Configuration
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB IS_SERVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
