# IAR project interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: stm32l151xB ST stm32l151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L1XX_MD; CFG_eu868; CFG_DEBUG; CFG_wimod_board; CFG_sx1272_radio; CFG_EXTI_IRQ_HANDLER=sensorirq
  ICCARM.CCDiagSuppress: Pa050, Pa089
  ICCARM.CCIncludePath2: ..\..\lmic-src; ..\..\lmic-src\HAL-STM32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: interrupt.hex
  ILINK.IlinkOutputFile: interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c sensor.c
  group LMIC
    ../../lmic-src/: aes.c hal.h lmic.c lmic.h lorabase.h oslmic.c oslmic.h radio.c
  group LMIC/HAL
    ../../lmic-src/HAL-STM32/: hal-stm32.c startup_stm32l1xx_md.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
