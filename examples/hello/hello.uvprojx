# Keil uVision project hello.uvprojx, settings and files
target hello (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hello
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_eu434 CFG_DEBUG CFG_x893_board CFG_RFM98W_radio CFG_noassert
  c include: ..\..\lmic-src;..\..\lmic-src\HAL-STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./: main.c
  group lmic-src
    ../../lmic-src/: oslmic.c lmic.c aes.c radio.c
  group HAL-STM32
    ../../lmic-src/HAL-STM32/: hal-stm32.c
    ../../lmic-src/HAL-STM32/MDK-ARM/: startup_stm32l1xx_md.s system_stm32l1xx.c
